Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Venice - Double Sunbed - v4.ifc
Time: 2023-11-10T15:53:55
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (20)
Name
 | d_19 - ObjectType: SketchupGroup
 | d_17 - ObjectType: SketchupGroup
 | d_18 - ObjectType: SketchupGroup
 | d_6 - ObjectType: SketchupGroup
 | d_5 - ObjectType: SketchupGroup
 | d_4 - ObjectType: SketchupGroup
 | d_3 - ObjectType: SketchupGroup
 | d_2 - ObjectType: SketchupGroup
 | d_1 - ObjectType: SketchupGroup
 | d_0 - ObjectType: SketchupGroup
 | d_7 - ObjectType: SketchupGroup
 | d_8 - ObjectType: SketchupGroup
 | d_9 - ObjectType: SketchupGroup
 | d_10 - ObjectType: SketchupGroup
 | d_11 - ObjectType: SketchupGroup
 | d_12 - ObjectType: SketchupGroup
 | d_13 - ObjectType: SketchupGroup
 | d_16 - ObjectType: SketchupGroup
 | d_15 - ObjectType: SketchupGroup
 | d_14 - ObjectType: SketchupGroup
